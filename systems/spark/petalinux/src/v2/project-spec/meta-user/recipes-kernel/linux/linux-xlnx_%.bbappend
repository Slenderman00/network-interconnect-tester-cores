SRC_URI += "file://user.cfg \
            file://fix_u96v2_pwrseq_simple.patch \
	    "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

