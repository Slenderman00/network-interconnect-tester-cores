SRC_URI += "file://user.cfg \
            file://axienet_common_mdio.patch \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

